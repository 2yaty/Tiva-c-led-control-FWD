# Keil uVision project Led Control.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Led Control
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MCAL\GPIO;.\MCAL\NVIC;.\MCAL\SysTick;.\LIBRARIES
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./App/: main.c
    ./MCAL/GPIO/: GPIO.c
    ./MCAL/NVIC/: NVIC.c
    ./MCAL/SysTick/: SysTick.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
